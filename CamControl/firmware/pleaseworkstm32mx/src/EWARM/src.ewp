# IAR project src.ewp, settings and files
configuration src (ARM, debug)
  General.OGChipSelectEditMenu: STM32WLE5CC ST STM32WLE5CC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: CORE_CM4; USE_HAL_DRIVER; STM32WLE5xx
  ICCARM.CCIncludePath2: ../Core/Inc; C:/Users/E/STM32Cube/Repository/STM32Cube_FW_WL_V1.4.0/Drivers/STM32WLxx_HAL_Driver/Inc; C:/Users/E/STM32Cube/Repository/STM32Cube_FW_WL_V1.4.0/Drivers/STM32WLxx_HAL_Driver/Inc/Legacy; C:/Users/E/STM32Cube/Repository/STM32Cube_FW_WL_V1.4.0/Drivers/CMSIS/Device/ST/STM32WLxx/Include; C:/Users/E/STM32Cube/Repository/STM32Cube_FW_WL_V1.4.0/Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: src.hex
  ILINK.IlinkOutputFile: src.out
  ILINK.IlinkIcfFile: stm32wle5xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32wle5xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32wlxx_it.c stm32wlxx_hal_msp.c
  group Drivers/STM32WLxx_HAL_Driver
    C:/Users/E/STM32Cube/Repository/STM32Cube_FW_WL_V1.4.0/Drivers/STM32WLxx_HAL_Driver/Src/: stm32wlxx_hal_uart.c stm32wlxx_hal_uart_ex.c stm32wlxx_hal_rcc.c stm32wlxx_hal_rcc_ex.c stm32wlxx_hal_flash.c stm32wlxx_hal_flash_ex.c stm32wlxx_hal_gpio.c stm32wlxx_hal_dma.c stm32wlxx_hal_dma_ex.c stm32wlxx_hal_pwr.c stm32wlxx_hal_pwr_ex.c stm32wlxx_hal_cortex.c stm32wlxx_hal.c stm32wlxx_hal_exti.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32wlxx.c
